# Keil uVision project T023.1903.uvprojx, settings and files
target T023.1903 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: T023.1903 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc; ..\User_Lib\App; ..\User_Lib\Control; ..\User_Lib\Ds18B20; ..\User_Lib\Keypad; ..\User_Lib\LedSeg;C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.0/Drivers/STM32F1xx_HAL_Driver/Inc;C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.0/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.0/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group App
    ../User_Lib/App/: app.c
  group Control
    ../User_Lib/Control/: control.c
  group Temperature
    ../User_Lib/Ds18B20/: ds18b20.c
  group Keypad
    ../User_Lib/Keypad/: keypad.c
  group Ledseg
    ../User_Lib/LedSeg/: ledSeg.c
  group Platform
    ../User_Lib/Platform/: debug.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/Admin/STM32Cube/Repository/STM32Cube_FW_F1_V1.8.0/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group PID
    ../User_Lib/pid/: pid.c
software components: CMSIS:CORE 4.3.0
